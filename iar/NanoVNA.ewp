# IAR project NanoVNA.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F072CB ST STM32F072CB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: ARM_MATH_CM0; M_PI=3.1415926535897932384626433832795
  ICCARM.PreInclude: githash.h
  ICCARM.CCIncludePath2: ..\; ..\NANOVNA_STM32_F072\; ..\ChibiOS\os\license\; ..\ChibiOS\os\rt\include\; ..\ChibiOS\os\various\shell\; ..\ChibiOS\os\common\oslib\include\; ..\ChibiOS\os\common\ext\CMSIS\include\; ..\ChibiOS\os\common\ext\CMSIS\ST\STM32F0xx\; ..\ChibiOS\os\common\startup\ARMCMx\; ..\ChibiOS\os\common\ports\ARMCMx\; ..\ChibiOS\os\common\ports\ARMCMx\compilers\IAR\; ..\ChibiOS\os\common\startup\ARMCMx\devices\STM32F0xx\; ..\ChibiOS\os\hal\include\; ..\ChibiOS\os\hal\osal\rt\; ..\ChibiOS\os\hal\lib\streams\; ..\ChibiOS\os\hal\ports\common\ARMCMx\; ..\ChibiOS\os\hal\ports\STM32\; ..\ChibiOS\os\hal\ports\STM32\LLD\TIMv1\; ..\ChibiOS\os\hal\ports\STM32\STM32F0xx\; ..\ChibiOS\os\hal\ports\STM32\LLD\DMAv1\; ..\ChibiOS\os\hal\ports\STM32\LLD\GPIOv2\; ..\ChibiOS\os\hal\ports\STM32\LLD\DACv1\; ..\ChibiOS\os\hal\ports\STM32\LLD\EXTIv1\; ..\ChibiOS\os\hal\ports\STM32\LLD\I2Cv2\; ..\ChibiOS\os\hal\ports\STM32\LLD\SPIv2\; ..\ChibiOS\os\hal\ports\STM32\LLD\RTCv2\; ..\ChibiOS\os\hal\ports\STM32\LLD\USARTv2\; ..\ChibiOS\os\hal\ports\STM32\LLD\USBv1\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\; ..\ChibiOS\os\license\; ..\ChibiOS\os\common\ports\ARMCMx\; ..\ChibiOS\os\common\startup\ARMCMx\devices\STM32F0xx\
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\NANOVNA_STM32_F072\ch.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; ARM_MATH_CM0; M_PI=3.1415926535897932384626433832795
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: NanoVNA.hex
  group src
    ../: adc.c dsp.c flash.c Font5x7.c ili9341.c main.c numfont20x22.c plot.c si5351.c tlv320aic3204.c ui.c usbcfg.c
  group src/ChibiOS/os/common/ports/ARMCMx
    ../ChibiOS/os/common/ports/ARMCMx/: chcore.c chcore_v6m.c
  group src/ChibiOS/os/common/ports/ARMCMx/compilers
    ../ChibiOS/os/common/ports/ARMCMx/compilers/IAR/: chcoreasm_v6m.s
  group src/ChibiOS/os/common/startup/ARMCMx/compilers
    ../ChibiOS/os/common/startup/ARMCMx/compilers/IAR/: cstartup.s vectors.s
  group src/ChibiOS/os/hal/lib/streams
    ../ChibiOS/os/hal/lib/streams/: chprintf.c memstreams.c
  group src/ChibiOS/os/hal/ports/common/ARMCMx
    ../ChibiOS/os/hal/ports/common/ARMCMx/: nvic.c
  group src/ChibiOS/os/hal/ports/STM32/LLD/DACv1
    ../ChibiOS/os/hal/ports/STM32/LLD/DACv1/: hal_dac_lld.c
  group src/ChibiOS/os/hal/ports/STM32/LLD/DMAv1
    ../ChibiOS/os/hal/ports/STM32/LLD/DMAv1/: stm32_dma.c
  group src/ChibiOS/os/hal/ports/STM32/LLD/EXTIv1
    ../ChibiOS/os/hal/ports/STM32/LLD/EXTIv1/: hal_ext_lld.c
  group src/ChibiOS/os/hal/ports/STM32/LLD/GPIOv2
    ../ChibiOS/os/hal/ports/STM32/LLD/GPIOv2/: hal_pal_lld.c
  group src/ChibiOS/os/hal/ports/STM32/LLD/I2Cv2
    ../ChibiOS/os/hal/ports/STM32/LLD/I2Cv2/: hal_i2c_lld.c
  group src/ChibiOS/os/hal/ports/STM32/LLD/RTCv2
    ../ChibiOS/os/hal/ports/STM32/LLD/RTCv2/: hal_rtc_lld.c
  group src/ChibiOS/os/hal/ports/STM32/LLD/SPIv2
    ../ChibiOS/os/hal/ports/STM32/LLD/SPIv2/: hal_i2s_lld.c hal_spi_lld.c
  group src/ChibiOS/os/hal/ports/STM32/LLD/TIMv1
    ../ChibiOS/os/hal/ports/STM32/LLD/TIMv1/: hal_gpt_lld.c hal_st_lld.c
  group src/ChibiOS/os/hal/ports/STM32/LLD/USARTv2
    ../ChibiOS/os/hal/ports/STM32/LLD/USARTv2/: hal_serial_lld.c
  group src/ChibiOS/os/hal/ports/STM32/LLD/USBv1
    ../ChibiOS/os/hal/ports/STM32/LLD/USBv1/: hal_usb_lld.c
  group src/ChibiOS/os/hal/ports/STM32/STM32F0xx
    ../ChibiOS/os/hal/ports/STM32/STM32F0xx/: hal_ext_lld_isr.c hal_lld.c
  group src/ChibiOS/os/hal/src
    ../ChibiOS/os/hal/src/: hal.c hal_buffers.c hal_dac.c hal_ext.c hal_gpt.c hal_i2c.c hal_i2s.c hal_queues.c hal_rtc.c hal_serial.c hal_serial_usb.c hal_spi.c hal_st.c hal_usb.c
  group src/ChibiOS/os/rt/src
    ../ChibiOS/os/rt/src/: chevents.c chmtx.c chregistry.c chschd.c chsys.c chthreads.c chvt.c
  group src/ChibiOS/os/various/shell
    ../ChibiOS/os/various/shell/: shell.c shell_cmd.c
  group src/header
    ../: chconf.h ffconf.h fft.h halconf.h mcuconf.h nanovna.h si5351.h usbcfg.h
    ./: githash.h
  group src/NANOVNA_STM32_F072
    ../NANOVNA_STM32_F072/: board.c ch.icf flash_config.c
